#include "pdcmac.h"

void PDC_beep(void)
{
    PDC_LOG(("PDC_beep() - called\n"));
    SysBeep(1);
}

void PDC_napms(int ms)
{
    long start;
    long waitticks;

    PDC_LOG(("PDC_napms() - called: ms=%d\n", ms));
    if (ms <= 0)
        return;
    waitticks = ((long)ms * 60L + 999L) / 1000L;
    if (waitticks < 1)
        waitticks = 1;
    start = TickCount();
    PDC_check_for_blinking();
    while (TickCount() - start < waitticks)
    {
        PDC_mac_process_events(1);
        PDC_check_for_blinking();
    }
}

const char *PDC_sysname(void)
{
    return "Mac";
}

enum PDC_port PDC_port_val = PDC_PORT_MAC;
